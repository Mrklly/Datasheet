<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hc32l130f8ua.ewp</path>
  </project>
  <batchBuild/>
</workspace>


