<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hc32l130e8pa.ewp</path>
  </project>
  <batchBuild/>
</workspace>


