# IAR project Backup of test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\user; ..\drive
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TEST.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group drive
    ../drive/: ADC2.c beep.c eeprom.c exit.c I2C.c led.c PWM.c SPI.c sys_config.c TIM1.c TIM2.c TIM3.c TIM4.c uart.c uart3.c
    ./: stm8s_interruput.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c
  group user
    ../drive/: chipID.c delay.c
    ./: main.c
